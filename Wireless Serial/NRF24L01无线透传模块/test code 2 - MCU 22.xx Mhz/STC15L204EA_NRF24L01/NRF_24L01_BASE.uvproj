# Keil uVision project NRF_24L01_BASE.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: NRF_24L01_BASE +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: NRF_24L01.C MAIN.C UART.C delay.c
